options:
  parameters:
    author: Timothee COCAULT
    category: TETRA
    description: Converts pi/4 DQPSK to type-5 bits
    generate_options: hb
    id: tetra_demod
    output_language: python
    title: TETRA Demod
  states: {}

blocks:
- name: bits_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: channel_samp_rate
  id: variable
  parameters:
    value: symbol_rate*samples_per_symbol
  states: {}
- name: constellation
  id: variable_constellation_rect
  parameters:
    const_points: '[1+1j, -1+1j, 1-1j, -1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: first_decim
  id: variable
  parameters:
    value: int(samp_rate/channel_samp_rate)
  states: {}
- name: low_pass
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: low_pass
    gain: '1.0'
    samp_rate: samp_rate
    width: low_pass*0.2
    win: window.WIN_HAMMING
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pre_channel_samp_rate
  id: variable
  parameters:
    value: samp_rate/float(first_decim)
  states: {}
- name: resampling_ratio
  id: variable
  parameters:
    value: pre_channel_samp_rate/channel_samp_rate
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: nfilts
    ntaps: 11*samples_per_symbol*nfilts
    samp_rate: nfilts
    sym_rate: 1.0/float(samples_per_symbol)
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '2'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 18e3
  states: {}
- name: symbols_per_timeslot
  id: variable
  parameters:
    value: '510'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: 1/(samples_per_symbol * symbols_per_timeslot)
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_diff_phasor_cc_0_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '45'
    rolloff: '0.35'
    samps_per_sym: samples_per_symbol
    type: cc
    w: cmath.pi/100
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: 2*cmath.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: samples_per_symbol
    taps: rrc_taps
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: offset
    decim: first_decim
    samp_rate: samp_rate
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: resampling_ratio
    type: complex
  states: {}
- name: offset
  id: parameter
  parameters:
    label: Offset
    type: eng_float
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: channel
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    type: eng_float
    value: 1e6
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', pad_sink_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [digital_diff_phasor_cc_0_0, '0', digital_constellation_decoder_cb_0_0, '0']
- [digital_diff_phasor_cc_0_0, '0', pad_sink_1_0, '0']
- [digital_fll_band_edge_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_diff_phasor_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', analog_agc_xx_0, '0']
- [mmse_resampler_xx_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
