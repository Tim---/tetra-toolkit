<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tetra_rx</value></param>
<param><key>author</key><value>Timothee COCAULT</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Receive and decode TETRA signal with a SDR</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>TETRA receiver</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>conf_center_freq</value></param>
<param><key>gui_hint</key><value>config_tab@0:0,0</value></param>
<param><key>label</key><value>Center Freq</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>conf_center_freq</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>100e6</value></param>
<param><key>option</key><value>center_freq</value></param>
<param><key>section</key><value>tetra_rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>center_freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>conf_fine</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>fine</value></param>
<param><key>section</key><value>tetra_rx</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>fine</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>conf_freq_corr</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>freq_corr</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>freq_corr</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>conf_rf_gain</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>10</value></param>
<param><key>option</key><value>rf_gain</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>rf_gain</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fine</value></param>
<param><key>value</key><value>conf_fine</value></param>
<param><key>gui_hint</key><value>config_tab@0:1,0</value></param>
<param><key>label</key><value>Fine freq</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-1e4</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>1e4</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>conf_freq_corr</value></param>
<param><key>gui_hint</key><value>config_tab@0:2,0</value></param>
<param><key>label</key><value>Freq Corr (ppm)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>conf_rf_gain</value></param>
<param><key>gui_hint</key><value>config_tab@0:3,0</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>60</value></param>
<param><key>rangeType</key><value>int</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>localhost</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>config_tab</value></param>
<param><key>gui_hint</key><value>:0,1,1,3</value></param>
<param><key>label0</key><value>Config</value></param>
<param><key>num_tabs</key><value>1</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>1</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>center_freq+fine</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>visu_tab@2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>36e3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>visu_tab@1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>visu_tab@0:0,0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>visu_tab@0:1,0</value></param>
<param><key>int_max</key><value>-40</value></param>
<param><key>int_min</key><value>-60</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>tetra_demod</key>
<param><key>id</key><value>tetra_demod_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>visu_tab</value></param>
<param><key>gui_hint</key><value>:0,0,1,1</value></param>
<param><key>label0</key><value>Coarse</value></param>
<param><key>label1</key><value>Channel</value></param>
<param><key>label2</key><value>Constellation</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>tetra_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tetra_demod_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tetra_demod_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tetra_demod_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
