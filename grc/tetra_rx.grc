options:
  parameters:
    author: Timothee COCAULT
    category: Custom
    description: Receive and decode TETRA signal with a SDR
    generate_options: qt_gui
    id: tetra_rx
    output_language: python
    title: TETRA receiver
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: config_tab@0:0,0
    label: Center Freq
    type: real
    value: conf_center_freq
  states: {}
- name: conf_center_freq
  id: variable_config
  parameters:
    config_file: default
    option: center_freq
    section: tetra_rx
    type: real
    value: 100e6
    writeback: center_freq
  states: {}
- name: conf_fine
  id: variable_config
  parameters:
    config_file: default
    option: fine
    section: tetra_rx
    type: real
    value: '0'
    writeback: fine
  states: {}
- name: conf_freq_corr
  id: variable_config
  parameters:
    config_file: default
    option: freq_corr
    section: main
    type: int
    value: '0'
    writeback: freq_corr
  states: {}
- name: conf_rf_gain
  id: variable_config
  parameters:
    config_file: default
    option: rf_gain
    section: main
    type: int
    value: '10'
    writeback: rf_gain
  states: {}
- name: fine
  id: variable_qtgui_range
  parameters:
    gui_hint: config_tab@0:1,0
    label: Fine freq
    start: '-1e4'
    step: 1e3
    stop: 1e4
    value: conf_fine
    widget: counter
  states: {}
- name: freq_corr
  id: variable_qtgui_range
  parameters:
    gui_hint: config_tab@0:2,0
    label: Freq Corr (ppm)
    rangeType: int
    start: '-50'
    step: '1'
    stop: '50'
    value: conf_freq_corr
    widget: counter
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: config_tab@0:3,0
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: conf_rf_gain
    widget: counter
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    eof: 'True'
    ipaddr: localhost
    port: '1234'
    psize: '1472'
    type: byte
  states: {}
- name: config_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: ':0,1,1,3'
    label0: Config
    num_tabs: '1'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    corr0: freq_corr
    dc_offset_mode0: '1'
    freq0: center_freq+fine
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: visu_tab@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: 36e3
    fc: '0'
    fftsize: '1024'
    gui_hint: visu_tab@1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: visu_tab@0:0,0
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: visu_tab@0:1,0
    int_max: '-40'
    int_min: '-60'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: tetra_demod_0
  id: tetra_demod
  parameters:
    offset: '0'
    samp_rate: samp_rate
  states: {}
- name: visu_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: ':0,0,1,1'
    label0: Coarse
    label1: Channel
    label2: Constellation
    num_tabs: '3'
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', tetra_demod_0, '0']
- [tetra_demod_0, '0', network_udp_sink_0, '0']
- [tetra_demod_0, '1', qtgui_freq_sink_x_0, '0']
- [tetra_demod_0, '2', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
